Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T16:14:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 16:14:32 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{AACE194D-91E3-4C2A-8ABC-33C1D7ECE7EB}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 16:14:31 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 16:14:31 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 16:14:31 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR084 - UTC 7, Panca JONATHAN:0PAAR084 - UTC 7:240204
In: 0 - Piano Terra
Type - Material: Default, Acciaio, UTC 7
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca JONATHAN
Type - Dati identità - BIM Name: JONATHAN; BIM Object Type: PANCHINE - BENCHES; Code: 0PAAR084; Designer: DEL PONTE, ZAMBELLI; Family Name: JONATHAN; Nome del tipo: 0PAAR084 - UTC 7; URL Eng: https://www.bellitalia.net/en/products/benches/jonathan/; URL Ita: https://www.bellitalia.net/prodotti/panchine/jonathan/
Type - Dimensioni - Dimensions: 3756 mm X 650 mm X h 450 mm H 738 mm
Type - Generale - Accessori: Gabbia in legno; Accessories: Wooden cage; Descrizione Tecnica Famiglia: "La panca mod. ”JONATHAN”, la cui forma rimanda a un gabbiano (da cui il nome tratto dall’omonimo libro), è costituita da una seduta monolitica a cui viene fissato un altro componente sospeso che costituisce, a livello ergonomico, un valido appoggio ischiatico o un pratico tavolino. La seduta monolitica viene, precedentemente fissata, a una base mascherata dalla pavimentazione in essere, che garantisce maggiore stabilità e sicurezza al prodotto."; Descrizione Tecnica per Codice: PANCA JONATHAN IN UTC® 7 - BIANCO LISCIO CASSERO VERNICIATURA ANTI-DEGRADO; Fissaggio: Plinto di fondazione in calcestruzzo; Fixings: Concrete foundation plinth; Technical Description Family: "The bench mod. ”JONATHAN”, whose shape refers to a seagull (hence the name taken from the homonymous book), is consisting of a monolithic seat to which it is fixed another suspended component that forms, at the level ergonomic, a valid ischial support or a practical one small table. The monolithic seat comes, previously fixed, to a base masked by the flooring be, which guarantees greater stability and security to the product."; Technical Description for Article: JONATHAN BENCH IN UTC® 7 - WHITE SMOOTH FORMWORK ANTI-DECAY VARNISH
Type - Materiali e finiture - MATERIALE BASE: Acciaio; Materiale Principale: UTC 7; Materiale Secondario: UTC; MATERIALE SEDUTA: UTC 7; Primary Material: UTC 7; Secondary Material: UTC
Type - Meccanica - Weight ( kg): 1110 Kg
Pset_BuildingElementProxyCommon - Reference: 0PAAR084 - UTC 7
Altro - Famiglia: Panca JONATHAN: 0PAAR084 - UTC 7; Famiglia e tipo: Panca JONATHAN: 0PAAR084 - UTC 7; ID tipo: Panca JONATHAN: 0PAAR084 - UTC 7; Tipo: Panca JONATHAN: 0PAAR084 - UTC 7
Dimensioni - Area: 4.88195 m2; Volume: 0.445007 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
